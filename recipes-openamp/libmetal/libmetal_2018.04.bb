SRCBRANCH ?= "master"
SRCREV = "606c31438025b9fb1515dace1c642d5835d8d33c"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=395307789d21fd8945fc1c933cad18b5"

include libmetal.inc

