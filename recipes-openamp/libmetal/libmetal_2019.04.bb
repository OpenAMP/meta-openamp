REPO ?= "git://github.com/Xilinx/libmetal.git;protocol=https"
SRCBRANCH ?= "master"
SRCREV ?= "823e4d00d32420439a1bab42d1a43b48f3fd00c8"
LIC_FILES_CHKSUM ?= "file://LICENSE.md;md5=fe0b8a4beea8f0813b606d15a3df3d3c"

include libmetal.inc

