SRCBRANCH ?= "master"
SRCREV = "ec0101ca9cfdffe23109458107a76e959e36353b"

include libmetal.inc

