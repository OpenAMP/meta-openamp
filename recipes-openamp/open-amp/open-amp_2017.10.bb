SRCBRANCH ?= "master"
SRCREV = "99069d1752fafa654f81f6a32dfcd2a256471634"

include open-amp.inc
