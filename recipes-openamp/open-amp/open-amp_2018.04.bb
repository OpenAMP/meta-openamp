SRCBRANCH ?= "master"
SRCREV = "de361adee09cd31793c60218a0ec49bc307a7410"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b30cbe0b980e98bfd9759b1e6ba3d107"

include open-amp.inc
