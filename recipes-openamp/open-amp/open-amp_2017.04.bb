SRCBRANCH ?= "master"
SRCREV ?= "ea35683b9550f000b702abad9be45b5357c744dd"

include open-amp.inc
