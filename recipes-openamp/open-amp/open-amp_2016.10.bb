SRCBRANCH ?= "master"
SRCREV ?= "9a117913e2950b7e37820ebc6178dc1452267f48"

include open-amp.inc
